# Keil uVision project TempCom2Pi.uvproj, settings and files
target TempCom2Pi (MCS-51)
  device: STC90C516RD+ STC-STC90
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xF3FF) CLOCK(45000000) MODP2
  output: TempCom2Pi
  c flags: Optimize=8 SizeSpeed=1
  group Source Group
    ./: Main.c MCP2515.c
  group Head Group
    ./: MCP2515.h
